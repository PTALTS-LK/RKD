# Repository PTALTS-LK/RKD

File README.md:

# 🚧🚧🚧 WIP 🚧🚧🚧
# 将在开发完成后正式开源，敬请期待
# RKD
### The RP2040-based Keyboard Devkit

###### *RKD V2 及更新版本的存储库 本存储库仅存储硬件设计图以及文档*

基于**RP2040 MCU**设计的一款低成本模块化四键小键盘开发板

默认固件设计用于音游使用场景

代码库基于**PlatformIO**(Arduino)重写，运行速度相较V1(MPY)更快，功能更多

硬件设计经过重做，布线更合理；精简外围元件，节省冗余成本；扩展接口IO扩增，开发潜力更广

全新基于Flutter开发的上位机，提供相较于V1串口指令设置更多的便捷性，更改设置通过专用串口协议

## ✨ Feature

### ✅ 已完成的功能

固件功能

###### *固件功能仅针对默认固件*

  - ✅ 基础按键检测与发送
    - 可选两种消抖方式
    - 6键无冲
  - ✅ 简易按键宏执行器
    - 按键宏可以通过上位机轻松设置
  - ✅ 板载 4 键位预设切换
    - 通过板载按钮+按键切换
  - ✅ 板载快速灯效调整
    - 通过板载按钮+按键切换
    - 可调节背光颜色、背光亮度、背光灯效
  - ✅ 使用情况统计
    - 按键次数、通电时间、etc .........

上位机功能
###### *上位机功能仅适用于默认固件*

  - ✅ 设置所有板载功能
    - 预设组、背光、etc.......
  - ✅ 简易宏编辑器
    - 快速设置简短按键宏
  - ✅ 预设编辑器
    - 配置每一组每一个键的功能
  - ✅ 文件浏览器
    - 上传下载查看板载文件系统的文件
    - 支持查看剩余空间
 - ✅ 固件上传与更新
    - 直接通过上位机更新板载固件
    - 无需进入RP2 Boot模式

### 🚧 计划中功能

###### *代码要一点一点敲，功能要一步一步实现，牙膏要一点一点挤.......*

###### *如果你有对于功能的建议，欢迎提出*

固件功能

 - 🚧 全键无冲
 - 🚧 长宏序列执行
 - etc .........

上位机功能

 - 🚧 实时按键显示(KeyViewer)
 - 🚧 安卓端适配
 - etc .........

扩展模块

 - SDVX
   - 继承自V1，将重新设计
 - 分体式按键扩展板
   - 你为什么要用两个独立主控的小键盘？
 - etc .........

## 🏗️ 开发环境/工具链 🛠️

###### *我偏向于使用开源工具链(也许是吧)作为我的开发环境 LOL*

  - Kicad
    - 硬件设计
  - VSCode
    - 代码编辑器
  - FreeCAD
    - 外壳3D设计
  - ArchLinux
    - 我的主力系统😎
    - Yes，所有开发都是在Linux上面进行的😎😎
    - ###### *不包括Windows上位机的开发移植以及兼容性测试 :P*

## KiCad design PCB/stand/MicroUSB/RKD.kicad_pcb

File PCB/README.md:

# PCB/原理图

- stand+sdvx :

  - 包含了主板和SDVX拓展板的PCB/原理图（单文件拼板）

- stand :

  - 只包含了主板PCB/原理图

子目录名称为对应接口版本的PCB/原理图

Parts:
C1, C2: 1u; C_0805_2012Metric
C3, C4: 27p; C_0805_2012Metric
C5, C6: 10u; C_0805_2012Metric
C7, C8, C9, C10, C11, C12, C13, C14, C15: 100n; C_0805_2012Metric
D1, D2, D3, D4: LED; L1206
H1, H2, H3, H4: MountingHole; HO
J1: USB_B_Micro; MICRO-USB-SMD_MICRO-4P-DIP-JB
J2, J4: Conn_02x02_Odd_Even; PinHeader_2x02_P2.54mm_Horizontal
J3, J5: Conn_02x04_Odd_Even; PinHeader_2x04_P2.54mm_Horizontal
J10: Conn_01x04_Male; XH-7mm
J11: Conn_02x06_Odd_Even; PinHeader_2x06_P2.54mm_Vertical
J12: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
J13: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J14, J15: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
K1, K2, K3, K4: Key
R1, R2, R5, R6, R7, R8: 27; R_0805_2012Metric
R3, R15: 1k; R_0805_2012Metric
R4: 4.7k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R9, R12: 0; R_0805_2012Metric
R13, R14, R16, R17: 1k 0805; R_0805_2012Metric
R18: 4.7k 0805; R_0805_2012Metric
SW2: SW_DIP_x04; SW_DIP_SPSTx04_Slide_9.78x12.34mm_W7.62mm_P2.54mm
SW3, SW5: SW_Push; SW_Push_1P1T_NO_6x6mm_H9.5mm
U1: W25Q32JV; SOIC-8_5.23x5.23mm_P1.27mm
U2: RP2040; RP2040-QFN-56
U3: CH9329; SOIC-16_3.9x9.9mm_P1.27mm
U4: AMS1117-33; SOT-223-3_TabPin2
Y1: Crystal 12MHZ HC49; Crystal_SMD_HC49-SD

Connections:
+1V1: C1.2, C7.2, C8.2, U2.23 (DVDD), U2.45 (VREG_VOUT), U2.50 (DVDD)
+3V3: C2.1, C6.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, J4.1, J11.1, J12.6, R13.2, R14.2, SW2.8, U1.8 (VCC), U2.1 (IOVDD), U2.10 (IOVDD), U2.22 (IOVDD), U2.33 (IOVDD), U2.42 (IOVDD), U2.43 (ADC_AVDD), U2.44 (VREG_IN), U2.48 (USB_VDD), U2.49 (IOVDD), U3.15 (VCC), U3.16 (V33), U4.2 (VO)
/22: J3.3, J11.11, U2.34 (GPIO22)
/23: J3.5, J11.9, U2.35 (GPIO23)
/24: J5.1, J12.4, U2.36 (GPIO24)
/25: J12.3, U2.37 (GPIO25)
/26: J3.7, J11.7, U2.38 (GPIO26_ADC0)
/27: J11.5, U2.39 (GPIO27_ADC1)
/28: J5.3, J12.2, U2.40 (GPIO28_ADC2)
/29: J5.5, J12.1, U2.41 (GPIO29_ADC3)
/ACT: D1.1 (K), U3.1 (ACT#)
/BOOT: R15.2, U1.1 (~CS), U2.56 (QSPI_SS)
/D+: J1.3 (D+), R12.1, U3.12 (UD+)
/D-: J1.2 (D-), R9.1, U3.13 (UD-)
/DEF: U2.7 (GPIO5), U3.10 (DEF)
/F1: J11.8, SW2.7, U2.8 (GPIO6)
/F2: J11.6, SW2.6, U2.9 (GPIO7)
/F3: J11.4, SW2.5, U2.11 (GPIO8)
/F-CLK: U1.6 (CLK), U2.52 (QSPI_SCLK)
/K1: J14.2, K1.2 (IO+), K1.4 (L-), U2.12 (GPIO9)
/K2: J14.3, K2.2 (IO+), K2.4 (L-), U2.13 (GPIO10)
/K3: J15.2, K3.2 (IO+), K3.4 (L-), U2.14 (GPIO11)
/K4: J15.3, K4.2 (IO+), K4.4 (L-), U2.15 (GPIO12)
/K5-H: J2.3, U2.17 (GPIO14)
/K6-H: J2.1, U2.18 (GPIO15)
/L1: K1.3 (L+), R5.1
/L2: K2.3 (L+), R6.1
/L3: K3.3 (L+), R7.1
/L4: K4.3 (L+), R8.1
/LED: J3.1, J4.3, J5.7, R5.2, R6.2, R7.2, R8.2, SW2.1
/MODE: J11.10, R17.2, U2.5 (GPIO3)
/PRESS: J11.12, R16.2, U2.4 (GPIO2)
/R+: R1.2, U2.47 (USB_DP)
/R-: R2.1, U2.46 (USB_DM)
/RA1-H: J3.8, U2.27 (GPIO16)
/RA2-H: J5.6, U2.30 (GPIO19)
/RB1-H: J3.6, U2.28 (GPIO17)
/RB2-H: J5.4, U2.31 (GPIO20)
/RP+: J10.3, R1.1, R12.2
/RP-: J10.2, R2.2, R9.2
/RS1-H: J3.4, U2.29 (GPIO18)
/RS2-H: J5.2, U2.32 (GPIO21)
/RUN: J11.2, SW5.2, U2.26 (RUN)
/SEL-H: J2.4, U2.16 (GPIO13)
/SET: U2.6 (GPIO4), U3.11 (SET)
/TR+: U2.3 (GPIO1), U3.7 (TXD)
/TR-: U2.2 (GPIO0), U3.8 (RXD)
/XIN: C3.2, U2.20 (XIN), Y1.2
/XOUT: R3.2, U2.21 (XOUT)
GND: C1.1, C2.2, C3.1, C4.1, C5.2, C6.2, C7.1, C8.1, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, D2.1 (K), D3.1 (K), D4.1 (K), J1.5 (GND), J1.6 (Shield), J2.2, J3.2, J4.2, J4.4, J5.8, J10.4, J11.3, J12.5, J13.2, J14.1, J14.4, J15.1, J15.4, K1.1 (GND), K2.1 (GND), K3.1 (GND), K4.1 (GND), R4.2, R18.2, SW2.2, SW2.3, SW2.4, SW3.1, SW5.1, U1.4 (GND), U2.19 (TESTEN), U2.57 (GND), U3.14 (GND), U4.1 (GND)
unnamed: C4.2, R3.1, Y1.1
unnamed: D1.2 (A), R14.1
unnamed: D2.2 (A), R16.1
unnamed: D3.2 (A), R13.1
unnamed: D4.2 (A), R17.1
unnamed: J13.1, U2.25 (SWD)
unnamed: J13.3, U2.24 (SWCLK)
unnamed: R15.1, SW3.2
unnamed: R4.1, R18.1, U3.9 (UP)
unnamed: U1.2 (DO(IO1)), U2.55 (QSPI_SD1)
unnamed: U1.3 (IO2), U2.54 (QSPI_SD2)
unnamed: U1.5 (DI(IO0)), U2.53 (QSPI_SD0)
unnamed: U1.7 (IO3), U2.51 (QSPI_SD3)
VBUS: C5.1, J1.1 (VBUS), J10.1, U4.3 (VI)

Notes on the sheet:
usb口连接切换 如果焊上0欧电阻则不能焊接CH9329 usb口会连接到rp2040
晶振二选一

Board: 2 copper layers, 100.0 x 56.5 mm, 109 parts (25 on the bottom side), 64 nets.

Other parts of the board:
kibuzzard-63A1C2D7: G***; kibuzzard-63A1C2D7
kibuzzard-64E6F2B1: G***; kibuzzard-64E6F2B1
kibuzzard-635D2D2A: G***; kibuzzard-635D2D2A
kibuzzard-635D2D3A: G***; kibuzzard-635D2D3A
kibuzzard-635D2D4F: G***; kibuzzard-635D2D4F
kibuzzard-635D2D9C: G***; kibuzzard-635D2D9C
kibuzzard-635D2DDA: G***; kibuzzard-635D2DDA
kibuzzard-635D2DF8: G***; kibuzzard-635D2DF8
kibuzzard-635D2E5E: G***; kibuzzard-635D2E5E
kibuzzard-635D2E8C: G***; kibuzzard-635D2E8C
kibuzzard-635E2F9D: G***; kibuzzard-635E2F9D
kibuzzard-6354ECAF: G***; kibuzzard-6354ECAF
kibuzzard-6354ECBE: G***; kibuzzard-6354ECBE
kibuzzard-6354ECDD: G***; kibuzzard-6354ECDD
kibuzzard-6354F0BA: G***; kibuzzard-6354F0BA
kibuzzard-6354F0CA: G***; kibuzzard-6354F0CA
kibuzzard-6354F005: G***; kibuzzard-6354F005
kibuzzard-6354F197: G***; kibuzzard-6354F197
kibuzzard-6358CBD1: G***; kibuzzard-6358CBD1
kibuzzard-6358CBDF: G***; kibuzzard-6358CBDF
kibuzzard-6358CBEF: G***; kibuzzard-6358CBEF
kibuzzard-6358CC01: G***; kibuzzard-6358CC01
kibuzzard-6358CC12: G***; kibuzzard-6358CC12
kibuzzard-6379A323: G***; kibuzzard-6379A323
kibuzzard-6379ABBC: G***; kibuzzard-6379ABBC
kibuzzard-6379ABEB: G***; kibuzzard-6379ABEB
kibuzzard-6379AC10: G***; kibuzzard-6379AC10
kibuzzard-6379AC21: G***; kibuzzard-6379AC21
kibuzzard-6379AD0A: G***; kibuzzard-6379AD0A
kibuzzard-6379AD2A: G***; kibuzzard-6379AD2A
kibuzzard-6379AD8B: G***; kibuzzard-6379AD8B
kibuzzard-6379AD17: G***; kibuzzard-6379AD17
kibuzzard-6379AD65: G***; kibuzzard-6379AD65
kibuzzard-6379AD71: G***; kibuzzard-6379AD71
kibuzzard-6379AD90: G***; kibuzzard-6379AD90
kibuzzard-6379AEA3: G***; kibuzzard-6379AEA3
kibuzzard-6379AEAA: G***; kibuzzard-6379AEAA
kibuzzard-6379AEAF: G***; kibuzzard-6379AEAF
kibuzzard-6379AEB5: G***; kibuzzard-6379AEB5
kibuzzard-6379AEB9: G***; kibuzzard-6379AEB9
kibuzzard-6379AEBD: G***; kibuzzard-6379AEBD
kibuzzard-6379AEE6: G***; kibuzzard-6379AEE6
kibuzzard-6379B2A2: G***; kibuzzard-6379B2A2
kibuzzard-6379B2B1: G***; kibuzzard-6379B2B1
kibuzzard-6379B2D0: G***; kibuzzard-6379B2D0
kibuzzard-6379B2D8: G***; kibuzzard-6379B2D8
kibuzzard-6379B29B: G***; kibuzzard-6379B29B

File PCB/stand/RKD_BOM.csv:

"Comment","Description","Designator","Footprint","LibRef","Pins","Quantity","PartNumber","url",
"1u","desc","C1,C2,","C_0805_2012Metric","libref","2","2","","",
"27p","desc","C3,C4,","C_0805_2012Metric","libref","2","2","","",
"10u","desc","C5,C6,","C_0805_2012Metric","libref","2","2","","",
"100n","desc","C7,C8,C9,C10,C11,C12,C13,C14,C15,","C_0805_2012Metric","libref","2","9","","",
"LED","desc","D1,D2,D3,D4,","L1206","libref","2","4","","",
"27","desc","R1,R2,R5,R6,R7,R8,","R_0805_2012Metric","libref","2","6","","",
"1k","desc","R3,R15,","R_0805_2012Metric","libref","2","2","","",
"1k 0805","desc","R13,R14,R16,R17,","R_0805_2012Metric","libref","2","4","","",
"4.7k 0805","desc","R18,","R_0805_2012Metric","libref","2","1","","",
"AP1117-33","desc","U4,","SOT-223-3_TabPin2","libref","4","1","","",
"Crystal 12MHZ HC49","desc","Y1,","Crystal_SMD_HC49-SD","libref","2","1","","",
"Crystal_GND24 12MHZ 3225","desc","Y2,","Crystal_SMD_3225-4Pin_3.2x2.5mm","libref","4","1","","",
"SW_Push","desc","SW3,SW5,","SW_Push_1P1T_NO_6x6mm_H9.5mm","libref","4","2","","",
"LOGO","desc","G***,","LOGO","libref","0","1","","",
"G***","desc","kibuzzard-63A1C2D7,","kibuzzard-63A1C2D7","libref","0","1","","",
"G***","desc","kibuzzard-6379A323,","kibuzzard-6379A323","libref","0","1","","",
"G***","desc","kibuzzard-6379ABBC,","kibuzzard-6379ABBC","libref","0","1","","",
"G***","desc","kibuzzard-6379ABEB,","kibuzzard-6379ABEB","libref","0","1","","",
"G***","desc","kibuzzard-6379AC10,","kibuzzard-6379AC10","libref","0","1","","",
"G***","desc","kibuzzard-6379AC21,","kibuzzard-6379AC21","libref","0","1","","",
"G***","desc","kibuzzard-6379AEA3,","kibuzzard-6379AEA3","libref","0","1","","",
"G***","desc","kibuzzard-6379AEAA,","kibuzzard-6379AEAA","libref","0","1","","",
"G***","desc","kibuzzard-6379AEAF,","kibuzzard-6379AEAF","libref","0","1","","",
"G***","desc","kibuzzard-6379AEB5,","kibuzzard-6379AEB5","libref","0","1","","",
"G***","desc","kibuzzard-6379AEB9,","kibuzzard-6379AEB9","libref","0","1","","",
"G***","desc","kibuzzard-6379AEBD,","kibuzzard-6379AEBD","libref","0","1","","",
"G***","desc","kibuzzard-6379AEE6,","kibuzzard-6379AEE6","libref","0","1","","",
"G***","desc","kibuzzard-6358CBD1,","kibuzzard-6358CBD1","libref","0","1","","",
"G***","desc","kibuzzard-6358CBDF,","kibuzzard-6358CBDF","libref","0","1","","",
"G***","desc","kibuzzard-6358CBEF,","kibuzzard-6358CBEF","libref","0","1","","",
"G***","desc","kibuzzard-6358CC01,","kibuzzard-6358CC01","libref","0","1","","",
"G***","desc","kibuzzard-6358CC12,","kibuzzard-6358CC12","libref","0","1","","",
"G***","desc","kibuzzard-635D2D2A,","kibuzzard-635D2D2A","libref","0","1","","",
"G***","desc","kibuzzard-635D2D3A,","kibuzzard-635D2D3A","libref","0","1","","",
"G***","desc","kibuzzard-635D2D4F,","kibuzzard-635D2D4F","libref","0","1","","",
"G***","desc","kibuzzard-635D2D9C,","kibuzzard-635D2D9C","libref","0","1","","",
"G***","desc","kibuzzard-635E2F9D,","kibuzzard-635E2F9D","libref","0","1","","",
"G***","desc","kibuzzard-6354ECAF,","kibuzzard-6354ECAF","libref","0","1","","",
"G***","desc","kibuzzard-6354ECBE,","kibuzzard-6354ECBE","libref","0","1","","",
"G***","desc","kibuzzard-6354ECDD,","kibuzzard-6354ECDD","libref","0","1","","",
"0","desc","R9,R12,","R_0805_2012Metric","libref","2","2","","",
"W25Q32JV","desc","U1,","SOIC-8_5.23x5.23mm_P1.27mm","libref","8","1","","",
"CH9329","desc","U3,","SOIC-16_3.9x9.9mm_P1.27mm","libref","16","1","","",
"OSHW-Logo_5.7x6mm_Copper","desc","REF**,","OSHW-Logo_5.7x6mm_Copper","libref","0","1","","",
"KiCad-Logo2_5mm_Copper","desc","REF**,","KiCad-Logo2_5mm_Copper","libref","0","1","","",
"G***","desc","kibuzzard-6379AD0A,","kibuzzard-6379AD0A","libref","0","1","","",
"G***","desc","kibuzzard-6379AD17,","kibuzzard-6379AD17","libref","0","1","","",
"G***","desc","kibuzzard-6379AD2A,","kibuzzard-6379AD2A","libref","0","1","","",
"G***","desc","kibuzzard-6379AD65,","kibuzzard-6379AD65","libref","0","1","","",
"G***","desc","kibuzzard-6379AD71,","kibuzzard-6379AD71","libref","0","1","","",
"G***","desc","kibuzzard-6379AD8B,","kibuzzard-6379AD8B","libref","0","1","","",
"G***","desc","kibuzzard-6379AD90,","kibuzzard-6379AD90","libref","0","1","","",
"G***","desc","kibuzzard-6379B29B,","kibuzzard-6379B29B","libref","0","1","","",
"G***","desc","kibuzzard-6379B2A2,","kibuzzard-6379B2A2","libref","0","1","","",
"G***","desc","kibuzzard-6379B2B1,","kibuzzard-6379B2B1","libref","0","1","","",
"G***","desc","kibuzzard-6379B2D0,","kibuzzard-6379B2D0","libref","0","1","","",
"G***","desc","kibuzzard-6379B2D8,","kibuzzard-6379B2D8","libref","0","1","","",
"G***","desc","kibuzzard-635D2DDA,","kibuzzard-635D2DDA","libref","0","1","","",
"G***","desc","kibuzzard-635D2DF8,","kibuzzard-635D2DF8","libref","0","1","","",
"G***","desc","kibuzzard-635D2E5E,","kibuzzard-635D2E5E","libref","0","1","","",
"G***","desc","kibuzzard-635D2E8C,","kibuzzard-635D2E8C","libref","0","1","","",
"G***","desc","kibuzzard-6354F005,","kibuzzard-6354F005","libref","0","1","","",
"G***","desc","kibuzzard-6354F0BA,","kibuzzard-6354F0BA","libref","0","1","","",
"G***","desc","kibuzzard-6354F0CA,","kibuzzard-6354F0CA","libref","0","1","","",
"G***","desc","kibuzzard-6354F197,","kibuzzard-6354F197","libref","0","1","","",
"Through Hole Items ",
"MountingHole","desc","H1,H2,H3,H4,","HO","libref","1","4","","",
"USB_B_Micro","desc","J1,","MICRO-USB-SMD_MICRO-4P-DIP-JB","libref","11","1","","",
"Conn_02x02_Odd_Even","desc","J2,J4,","PinHeader_2x02_P2.54mm_Horizontal","libref","4","2","","",
"Conn_02x04_Odd_Even","desc","J3,J5,","PinHeader_2x04_P2.54mm_Horizontal","libref","8","2","","",
"Conn_01x04_Male","desc","J10,","XH-7mm","libref","4","1","","",
"Conn_02x06_Odd_Even","desc","J11,","PinHeader_2x06_P2.54mm_Vertical","libref","12","1","","",
"Conn_01x06","desc","J12,","PinHeader_1x06_P2.54mm_Vertical","libref","6","1","","",
"Conn_01x03","desc","J13,","PinHeader_1x03_P2.54mm_Vertical","libref","3","1","","",
"Conn_01x04","desc","J14,J15,","PinHeader_1x04_P2.54mm_Vertical","libref","4","2","","",
"Key","desc","K1,K2,K3,K4,","Key","libref","17","4","","",
"4.7k","desc","R4,","R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal","libref","2","1","","",
"RP2040","desc","U2,","RP2040-QFN-56","libref","70","1","","",
"SW_DIP_x04","desc","SW2,","SW_DIP_SPSTx04_Slide_9.78x12.34mm_W7.62mm_P2.54mm","libref","8","1","","",

## Commit log (part)

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2022-10-21 Create LICENSE
2022-11-24 rename
2022-12-15 Rename ag
2023-01-21 init
2023-01-30 添加stand分离版本
2023-01-30 TypeC版本init
2023-01-30 fix files
2023-01-30 fix pcb
2023-01-30 fix doc
2023-02-04 修复typec版本的接口只能在特定一面使用
2023-02-12 add gitignore
2023-02-12 upd code
2023-03-12 upd pcb and md
2023-03-12 upd doc
2023-03-12 upd sub MPY_code
2023-04-30 添加BOM.md以及同步mpy代码
2023-05-13 1.0 pre
2023-07-06 doc upd key_map
2023-08-15 upd doc bom
2023-08-17 upd gerber
2023-08-17 upd bom.md
2023-08-19 紧急修复:经验证3225晶振无法稳定起振,故去除所以文件中的3225晶振
2023-08-23 sync rename
2023-09-16 doc upd
2023-09-17 主控升级
2023-09-17 sync code fix
2023-09-23 sync code
2023-11-26 更新,py代码重构,sdvx版pcb修改
2024-01-26 add pinout
2024-01-26 pinout upd
2024-01-31 upd cdc_setting.md
2024-02-03 upd key_map.md
2024-03-24 upd doc cdc_setting.md
2024-05-12 主控更新,文档更新
